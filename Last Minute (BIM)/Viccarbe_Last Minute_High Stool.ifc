Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2016-05-25T15:49:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140322_1515(x64) - Exporter 2015.0.2014.0322 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed May 25 15:49:41 2016 * Host: DESKTOP-JPLJHI2 * Database: C:\Users\Esteban\AppData\Local\Temp\{85FA5A46-A04B-46FA-B85D-8196BE7DCC7D}\ifc * Database version: 5507 * Database creation date: Wed May 25 15:49:40 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed May 25 15:49:40 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed May 25 15:49:40 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: C:\Users\Esteban\Desktop\Catalogos\Modificados\Last Minute\Viccarbe_Last Minute_High Stool.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: High Stool, Viccarbe_Last Minute:High Stool:4221
In: Level 1
Type - ElementType: High Stool; Material: Chrome Steel, Plastic, Sand, Plastic, White, Steel, Paint Finish, White
Type - Construction - High Stool Legs: yes; Low Stool Legs: no; Medium Stool Legs: no
Type - Dimensions - Depth (inches): 16.92''; Depth (mm): 430 mm; Height (inches): 31.50''; Height (mm): 800 mm; Width (inches): 17.32''; Width (mm): 440 mm
Type - Identity Data - Collection: LAST MINUTE; Content Revision Date: 21/04/2016; Description: Indoor & outdoor stool. Rotomoulded polyethylene seat and lacquered steel frame with stainless steel footrest. Its structural design has become a contemporary classic.; Designer: PATRICIA URQUIOLA; Essays BIFMA: http://www.viccarbe.com/archivos/viccarbe-test-last-minute-bifma-en.pdf; Essays UNE: http://www.viccarbe.com/archivos/viccarbe-test-last-minute-une-en.pdf; General Dimensions (inches): 17.32"x16.92"x31.50"; General Dimensions (mm): 44x43x80 cm; Information Expiry Date: 01/01/2017; Manufacturer: VICCARBE; Model: HIGH; OmniClass Number: 23.40.20.00; OmniClass Title: General Furniture and Specialties; Product Contact Email: info@viccarbe.com; Product Contact Telephone: +34 96 120 10 10; Product Service Life: -; Product URL: http://www.viccarbe.com/product.php?id=424dade6dbd45ab; Reference Code: LMA; Series: -; Technical information: http://www.viccarbe.com/archivos/viccarbe-last-minute-en-72.pdf; Terms and Conditions of Sale: See the conditions on the pricelist.; Type Name: High Stool; URL: http://www.viccarbe.com/; Warranty: 5 YEARS; Warranty URL: http://www.viccarbe.com/quality.php
Type - Materials and Finishes - Bar Protection Material: Chrome Steel; Base Material: Steel, Paint Finish, White; Frame Material: Steel, Paint Finish, White; Glides Material: Plastic, White; Materials - Fabrics: http://www.viccarbe.com/archivos/VICCARBE_Kvadrat_fabrics.pdf; Materials - Leather: http://www.viccarbe.com/archivos/VICCARBE_leather.pdf; Materials - Vinyl: http://www.viccarbe.com/archivos/VICCARBE_polipiel_vinyl.pdf; Seat Material: Plastic, Sand
Type - Other - Category: Furniture; Family Name: Viccarbe_Last Minute; Seat Heigh_Model: 790 mm; Suports distance: 5 mm
Pset_ManufacturerTypeInformation - Manufacturer: VICCARBE
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.472126 m2; Volume: 0.00787631 m3
Other - Family: Viccarbe_Last Minute: High Stool; Family and Type: Viccarbe_Last Minute: High Stool; Type: Viccarbe_Last Minute: High Stool; Type Id: Viccarbe_Last Minute: High Stool
Phasing - Phase Created: New Construction
